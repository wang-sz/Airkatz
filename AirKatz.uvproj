# Keil uVision project AirKatz.uvproj, settings and files
target AirKatz (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: AirKatz
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: Startup.s ADC.c DAC.c PLL.c Sound.c ST7735.c LCD.s Print.s Switch.c Timer0.c AirKatz.c Buffer.c random.s UART.c
  group Header Files
    ./: ADC.h DAC.h LCD.h PLL.h print.h Sound.h ST7735.h tm4c123gh6pm.h Timer0.h images.h TExaS.h Buffer.h sounds.h Switch.h random.h UART.h
